# Keil uVision project Myproj.uvprojx, settings and files
target STM32F429 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: Myproj +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin -o .\U盘\update\data_v0.0.0.bin .\OutPut\Myproj.axf
  AfterMake: ..\RVMDK\Keil5_disp_size_bar_v0.3.exe
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_GD=0
  c misc: --locale=english --C99
  c include: ..\bsp;..\Libraries;..\Libraries\inc;..\uCOS-II\port;..\uCOS-II\src;..\uCOS-II;..\uCGUI;..\uCGUI\Config;..\uCGUI\inc;..\uCGUI\uCGUIDemo;..\FatFS;..\Interface;..\bsp\USB_APP;..\Libraries\USB_Libraries\STM32_USB_OTG_Driver\inc;..\Libraries\USB_Libraries\STM32_USB_HOST_Library\Core\inc;..\Libraries\USB_Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\app;..\Interface\PIC
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: main.c
    ../app/: APP.C BSP.C MyTask.c DataSave.C Recode.C encrypt.c Protocol.c Energy.c dlt645.c modbus.c cjt188.c md5.c Trial_Ver.c app_daytemp_cal.c
  group BSP
    ../bsp/: W25QXX.C System_Printf.c Common.c Usart.c PCF8563.C EEPROM.c DIN.c PWM_OUT.c AD7327.c JDQ.c
  group Interface
    ../Interface/: NumInput.c MMain_Task.c MDev_Man.c Menu_Pub.c MDev_SetSensor.c MDev_FixedSpeedfan.c MDev_Heater.c MDev_Regulatingfan.c MDev_SetLight.c MDev_SignalInput.c MDev_Window.c Parameters.c MWarning.c MCtrl_Man.c MCtrl_MinAir.c MCtrl_TempCurve.c MSys_Man.c MDev_Spray.c MDev_Wet.c MMessage.c MSys_Day.c MSys_Room.c MSys_Total.c MAla_Record.c MSys_HardTS.c MSys_JDQTS.c MSys_PWMTS.c MData_Record.c MUser_Man.c MUser_PwdCG.c MDev_Circle.c MDev_Timer.c MCtrl_Assist.c MBasic_Main.c MCtrl_VAC.c MSys_AlaTS.c MSys_TimeSet.c MCtrl_OTSensor.c MDev_Produce.c MDev_ProduceHis.c MDev_ProduceCur.c MSys_SLTS.c MPic_Show.c MDev_ASSensor.c MCtrl_Var.c MCtrl_LVView.c MCtrl_TempView.c MCtrl_LVFAN_SET.c MSys_SysSet.c MDev_ModbusSet.c MDev_PHeater.c MBasic_Main2.c MDev_JdqView.c MSys_CommSet.c MDev_Tempc.c MHis_TempView.c MData_TempView.c MDev_APWM_FAN.c MDev_FanChk.c SourceCode.c MStart_Record.c MDev_ProduceMore.c MCtrl_exMinAir.c MDev_FoodADJ.c MCtrl_HumFix.c MCtrl_HumFix_Set.c MCtrl_LVView_Set.c MCtrl_TempCurve_Set.c MSys_ParManager.c MAla_En.c MCtrl_Defrost.c MSys_SensorRG.c MDev_Swin.c MDev_Window_Set.c MCtrl_VAC_Set.c MSys_InSel.c MDev_Tempc_Set.c MDev_SetSensor_Set.c MDev_Tempc_Pwm.c MCtrl_Man_More.c MMain_SS.c MClock_Record.c MCtrl_DayTemp.c MDev_Water_Set.c
  group STM32_SRC
    ../Libraries/: system_stm32f4xx.c startup_stm32f429_439xx.s stm32f4xx_it.c
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_iwdg.c stm32f4xx_exti.c stm32f4xx_dma2d.c stm32f4xx_fmc.c stm32f4xx_ltdc.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_flash.c
  group OS_SRC
    ../uCOS-II/src/: os_core.c os_task.c os_time.c os_sem.c os_mbox.c os_mutex.c
  group PORT
    ../uCOS-II/port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
    ../uCOS-II/: app_cfg.h os_cfg.h
  group GUI_X
    ../uCGUI/: GUI_X_uCOS.c GUI_X_Touch.c
  group GUI_LIB
    ../uCGUI/Lib/: STemWin532_CM3_Keil.lib
  group LCDDriver
    ../uCGUI/: ADS7843.c Tslib_Calibration.C stm324x9i_eval_lcd.c SDRAM.c GUI_FontYH_16.c GUI_FontYH_36.c GUI_FontYH_24.c GUI_FontCY_72.c
  group Config
    ../uCGUI/Config/: GUIConf.h GUIConf.c LCDConf_Lin_Template.c
  group FatFS
    ../FatFS/: CCSBCS.C diskio.c ff.c
    ../bsp/: sdio_sdcard.c
  group USB_APP
    ../bsp/USB_APP/: usb_bsp.c usb_bsp.h usb_conf.h usbh_conf.h usbh_usr.c usbh_usr.h
  group USB_OTG_Driver
    ../Libraries/USB_Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST_LIB
    ../Libraries/USB_Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../Libraries/USB_Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group ReadMe
    ../: ReadMe.txt
target GD32F470 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Myproj +hex
  AfterMake: E:\Keil_v5\ARM\ARM_Compiler_5.06u7\bin\fromelf.exe  --bin -o .\U盘\update\data_v0.0.0.bin .\OutPut\Myproj.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_GD=1
  c misc: --locale=english --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.5.0
