/*
** brief : impletment modbus protocol
** author: commsky
** date  : 2019-4-1
*/

#include <stdio.h>
#include <math.h>
#include <string.h>

#include "modbus.h"



#define INIT_CRC	(0xFFFF)
#define CRC_POLY	(0xA001)

/*
* brief   : get crc code
* param   : msg[in]:message buffer
*           ln[in]:message length
* result  : crc code
*/
WORD GetCRC( BYTE* msg, int ln )
{
    int		i, j;
    WORD	wCrc = INIT_CRC;

    if ( msg == NULL || ln < 1 ) {
        return wCrc;
    }

    for ( i = 0; i < ln; i++ ) {
        wCrc ^= msg[i];

        for ( j = 0; j < 8; j++ ) {
            wCrc >>= 1;

            if ( wCrc & 0x01 ) {
                wCrc ^= CRC_POLY;
            }
        }
    }

    return wCrc;
}

/*
* brief   : get lrc code
* param   : msg[in]:message buffer
*           ln[in]:message length
* result  : lrc code
*/
int GetLRC( BYTE* msg, int ln )
{
    int		i;
    BYTE	bLrc = 0;

    if ( msg == NULL || ln < 1 ) {
        return -1;
    }

    for ( i = 0; i < ln; i++ ) {
        bLrc += msg[i];
    }

    return ~bLrc;
}

/* 高位字节的 CRC 值 */
const BYTE CRCHi[] = {
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,
    0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40
};

/* 低位字节的 CRC 值 */
const BYTE CRCLo[] = {
    0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06,
    0x07, 0xC7, 0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD,
    0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09,
    0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A,
    0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC, 0x14, 0xD4,
    0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
    0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3,
    0xF2, 0x32, 0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4,
    0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,
    0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29,
    0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF, 0x2D, 0xED,
    0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
    0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60,
    0x61, 0xA1, 0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67,
    0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F,
    0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68,
    0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA, 0xBE, 0x7E,
    0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
    0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71,
    0x70, 0xB0, 0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92,
    0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C,
    0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B,
    0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89, 0x4B, 0x8B,
    0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
    0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42,
    0x43, 0x83, 0x41, 0x81, 0x80, 0x40
};

WORD GetCRCDict( BYTE *msg, int ln )
{
    int		index;
    BYTE bCRCHi = 0xFF; // CRC 的高字节初始化
    BYTE bCRCLo = 0xFF; // CRC 的低字节初始化

    if ( msg == NULL || ln < 1 ) {
        return 0xFFFF;
    }

    while ( ln--) {
        index = bCRCLo ^ *msg++;
        bCRCLo = bCRCHi ^ CRCHi[index];
        bCRCHi = CRCLo[index];
    }

    return (bCRCHi << 8 | bCRCLo);
}

WORD GetCRC16( BYTE *msg, int ln, WORD crc )
{
    int		index;
    BYTE bCRCHi = (BYTE)(crc >> 8); // CRC 的高字节初始化
    BYTE bCRCLo = (BYTE)crc; // CRC 的低字节初始化

    if ( msg == NULL || ln < 1 ) {
        return 0xFFFF;
    }

    while ( ln--) {
        index = bCRCLo ^ *msg++;
        bCRCLo = bCRCHi ^ CRCHi[index];
        bCRCHi = CRCLo[index];
    }

    return (bCRCHi << 8 | bCRCLo);
}



/*
* brief : get register number from data-bytes
* param : pApIt[in]:ap pointer
* result: -1:param error
*        >=0:register number
*/
//int MODBUS_GetRegNum( PAP_PARM pApIt )
//{
//	int		nReg;
//
//	if( pApIt==NULL ){
//		return -1;
//	}
//
//	nReg=0;
//	switch( pApIt->func )
//	{
//	case COM_RD_SCOIL:
//	case COM_RD_SIN:
//	case COM_WR_COIL_x:
//		nReg=pApIt->start+pApIt->len;
//		break;
//	default:
//		nReg=(pApIt->start+pApIt->len+1)/2;
//		break;
//	}
//
//	return nReg;
//}

/*
* brief : package modbus message
* param : addr[in]:dev addr
*         func[in]:control
*         reg[in]:reg
*         regn[in]:reg number
*         buf[in]:buffer
*         size[in]:buffer size
* result: -1:param error
*         >0:message length
*/
int MODBUS_PackMsg( BYTE addr, BYTE func, BYTE* reg, BYTE regn, BYTE* buf, int size )
{
    int		it;
    WORD	wCrc;
    PSL_PDU_RD	pPduR;

    if ( reg == NULL || buf == NULL ||
            size < sizeof(TSL_PDU_RD) ) {
        return -1;
    }

    pPduR = (PSL_PDU_RD)buf;
    pPduR->addr = addr;
    pPduR->pdu.func = func;
    pPduR->pdu.addr.x[0] = reg[1]; // msb
    pPduR->pdu.addr.x[1] = reg[0]; // lsb
    pPduR->pdu.num.x[0] = 0;
    pPduR->pdu.num.x[1] = regn;

    it = 1 + sizeof(TPDU_RD);
    wCrc = GetCRCDict( buf, it );
    buf[it++] = wCrc & 0xff;
    buf[it++] = (wCrc >> 8) & 0xff;

    return it;
}

int MODBUS_WriteMsg( BYTE addr, BYTE func, BYTE* reg, BYTE* data, BYTE* buf, int size )
{
    int		it;
    WORD	wCrc;
    PSL_PDU_WD	pPduW;

    if ( reg == NULL || buf == NULL || data == NULL ||
            size < sizeof(TSL_PDU_WD) ) {
        return -1;
    }

    pPduW = (PSL_PDU_WD)buf;
    pPduW->addr = addr;
    pPduW->pdu.func = func;
    pPduW->pdu.addr.x[0] = reg[1]; // msb
    pPduW->pdu.addr.x[1] = reg[0]; // lsb
    pPduW->pdu.value.x[0] = data[1]; // msb
    pPduW->pdu.value.x[1] = data[0]; // lsb

    it = 1 + sizeof(TPDU_WD);
    wCrc = GetCRCDict( buf, it );
    buf[it++] = wCrc & 0xff;
    buf[it++] = (wCrc >> 8) & 0xff;

    return it;
}


/*
* brief : get modbus data segment
* param : addr[in]:device address
*         func[in]:fun code
*         buf[in/out]:message buffer
*         msgLn[in]:message length
* result: <0:error
*         =0:ctrl error
*         >0:data length
*/
int MODBUS_GetDatSeg( BYTE addr, BYTE func, BYTE* buf, int msgLn )
{
    int		it, bytes;
    WORD	wCRC1, wCRC2;
    BYTE*	pItData;
    PSL_PDUA_HEAD	pHeadA;

    if ( buf == NULL || msgLn < sizeof(TSL_PDUA_HEAD) ) {
        return -1;
    }

    for ( it = 0; it < msgLn; it++ ) {
        if ( buf[it] == addr ) {
            break;
        }
    }

    if ( (msgLn - it) < sizeof(TSL_PDUA_HEAD) ) {
        return -2;
    }

    pHeadA = (PSL_PDUA_HEAD)&buf[it];

    // check address and control code
    if ( pHeadA->addr != addr 
		/*||pHeadA->pdu.func != func*/ ) {
        return -3;
    }

    // check crc code
    wCRC1 = GetCRCDict( &pHeadA->addr, msgLn - it - 2 );
    wCRC2 = (buf[msgLn - it - 1] << 8) | buf[msgLn - it - 2];

    if ( wCRC1 != wCRC2 ) {
        return -4;
    }

    // pick data
    bytes = pHeadA->pdu.bytes;
    pItData = &pHeadA->pdu.data;
    memcpy( buf, pItData, bytes );

    return bytes;
}

int MODBUS_GetWrAck( BYTE addr, BYTE func, BYTE* reg, BYTE* data, BYTE* buf, int msgLn )
{
    int		it;
    WORD	wCRC1, wCRC2;
    PSL_PDUA_WHEAD	pHeadA;

    if ( buf == NULL || msgLn < sizeof(TSL_PDUA_WHEAD) ) {
        return -1;
    }

    for ( it = 0; it < msgLn; it++ ) {
        if ( buf[it] == addr ) {
            break;
        }
    }

    if ( (msgLn - it) < sizeof(TSL_PDUA_WHEAD) ) {
        return -2;
    }

    pHeadA = (PSL_PDUA_WHEAD)&buf[it];

    // check address and control code
    if ( pHeadA->addr != addr ||
            pHeadA->pdu.func != func ) {
        return -3;
    }

    // check crc code
    wCRC1 = GetCRCDict( &pHeadA->addr, msgLn - it - 2 );
    wCRC2 = (buf[msgLn - it - 1] << 8) | buf[msgLn - it - 2];

    if ( wCRC1 != wCRC2 ) {
        return -4;
    }

    // check code
    if (	pHeadA->pdu.addr.x[0] != reg[1] || // msb
            pHeadA->pdu.addr.x[1] != reg[0] || // lsb
            pHeadA->pdu.value.x[0] != data[1] || // msb
            pHeadA->pdu.value.x[1] != data[0]) { // lsb
        return -5;
    }

    return 1;
}


